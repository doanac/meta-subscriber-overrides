SRCREV = "bc56368f6921dd4050064c3547c53b853bbc34e8"
#SRC_URI = "git://github.com/doanac/lmp-device-register.git;protocol=https;branch=overwrite-help"
